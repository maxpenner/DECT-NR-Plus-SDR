options:
  parameters:
    author: Maxim Penner
    generate_options: qt_gui
    id: usrp_calibration_power_rx
    output_language: python
    title: usrp_calibration_power_rx
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 0.5e9
    step: 100e6
    stop: 6.0e9
    value: 0.5e9
  states: {}
- name: gain_rx
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '120'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12.5e6
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Upper USRP Source: N-Series
      Lower USRP Source: B-Series

      Measurement setup: Agilent E4438X + Coax/Mini-Circuits + DC-Blocker + Coax/Mini-Circuits + RX0

      NOTE: For B-series, run"export UHD_IMAGES_DIR=/usr/local/share/uhd/images."

      --------------------------------------------------------------------------
      N310 14323100-2019-009

      RX 0.5GHz+200kHz Gain 75 dB: -6 dBFS (0.5 Vp 1.0 Vpp) at -42.20 dBm
      RX 1.0GHz+200kHz Gain 75 dB: -6 dBFS (0.5 Vp 1.0 Vpp) at -41.60 dBm
      RX 2.0GHz+200kHz Gain 75 dB: -6 dBFS (0.5 Vp 1.0 Vpp) at -41.30 dBm
      RX 2.5GHz+200kHz Gain 75 dB: -6 dBFS (0.5 Vp 1.0 Vpp) at -39.60 dBm
      RX 3.0GHz+200kHz Gain 75 dB: -6 dBFS (0.5 Vp) 1.0 Vpp at -39.20 dBm
      RX 3.2GHz+200kHz Gain 75 dB: -6 dBFS (0.5 Vp) 1.0 Vpp at -38.00 dBm
      RX 3.5GHz+200kHz Gain 75 dB: -6 dBFS (0.5 Vp) 1.0 Vpp at -37.20 dBm
      RX 4.0GHz+200kHz Gain 75 dB: -6 dBFS (0.5 Vp 1.0 Vpp) at -37.20 dBm
      RX 4.5GHz+200kHz Gain 75 dB: -6 dBFS (0.5 Vp 1.0 Vpp) at -37.20 dBm
      RX 5.0GHz+200kHz Gain 75 dB: -6 dBFS (0.5 Vp 1.0 Vpp) at -36.10 dBm
      RX 5.5GHz+200kHz Gain 75 dB: -6 dBFS (0.5 Vp 1.0 Vpp) at -34.40 dBm
      RX 5.9GHz+200kHz Gain 75 dB: -6 dBFS (0.5 Vp 1.0 Vpp) at -32.90 dBm

      --------------------------------------------------------------------------
      N321

      ToDo

      --------------------------------------------------------------------------
      B210 31EAC37

      RX 1.0GHz+200kHz Gain 76 dB: -6 dBFS (0.5 Vp 1.0 Vpp) at -53.00 dBm
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '100'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    dev_addr: '"addr=192.168.30.2"'
    gain0: gain_rx
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    dev_addr: '"serial=31EAC37"'
    dev_args: '"type=b200,master_clock_rate=30.72e6"'
    gain0: gain_rx
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
