options:
  parameters:
    author: Maxim Penner
    generate_options: qt_gui
    id: tcp_scope
    output_language: python
    title: tcp_scope
  states: {}

blocks:
- name: Number_of_Points
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Y_max
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Y_min
  id: variable
  parameters:
    value: '-4'
  states: {}
- name: port_ant_0
  id: variable
  parameters:
    value: '2200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: trigger_delay
  id: variable
  parameters:
    value: Number_of_Points/2/samp_rate
  states: {}
- name: trigger_level
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: update_period
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: network_tcp_source_0_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: port_ant_0+7
    server: 'True'
    type: complex
  states: {state: disabled}
- name: network_tcp_source_0_0_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: port_ant_0+6
    server: 'True'
    type: complex
  states: {state: disabled}
- name: network_tcp_source_0_0_1
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: port_ant_0+5
    server: 'True'
    type: complex
  states: {state: disabled}
- name: network_tcp_source_0_0_2
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: port_ant_0+4
    server: 'True'
    type: complex
  states: {state: disabled}
- name: network_tcp_source_0_0_3
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: port_ant_0+3
    server: 'True'
    type: complex
  states: {state: disabled}
- name: network_tcp_source_0_0_4
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: port_ant_0+2
    server: 'True'
    type: complex
  states: {state: disabled}
- name: network_tcp_source_0_0_5
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: port_ant_0+1
    server: 'True'
    type: complex
  states: {state: disabled}
- name: network_tcp_source_0_0_6
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: port_ant_0
    server: 'True'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: Number_of_Points
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_4_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    nconnections: '4'
    size: Number_of_Points
    srate: samp_rate
    tr_delay: trigger_delay
    tr_level: trigger_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: update_period
    ylabel: Ch_0_1_2_3_4_5_6_7
    ymax: Y_max
    ymin: Y_min
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_4_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    nconnections: '4'
    size: Number_of_Points
    srate: samp_rate
    tr_delay: trigger_delay
    tr_level: trigger_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: update_period
    ylabel: Ch_0_1_2_3
    ymax: Y_max
    ymin: Y_min
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_4_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    nconnections: '2'
    size: Number_of_Points
    srate: samp_rate
    tr_delay: trigger_delay
    tr_level: trigger_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: update_period
    ylabel: Ch_0_1
    ymax: Y_max
    ymin: Y_min
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_4_0_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: Number_of_Points
    srate: samp_rate
    tr_delay: trigger_delay
    tr_level: trigger_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: update_period
    ylabel: Ch_0
    ymax: Y_max
    ymin: Y_min
  states: {state: disabled}

connections:
- [network_tcp_source_0_0, '0', qtgui_time_sink_x_0_0_4_0, '3']
- [network_tcp_source_0_0_0, '0', qtgui_time_sink_x_0_0_4_0, '2']
- [network_tcp_source_0_0_1, '0', qtgui_time_sink_x_0_0_4_0, '1']
- [network_tcp_source_0_0_2, '0', qtgui_time_sink_x_0_0_4_0, '0']
- [network_tcp_source_0_0_3, '0', qtgui_time_sink_x_0_0_4_0_0, '3']
- [network_tcp_source_0_0_4, '0', qtgui_time_sink_x_0_0_4_0_0, '2']
- [network_tcp_source_0_0_5, '0', qtgui_time_sink_x_0_0_4_0_0, '1']
- [network_tcp_source_0_0_5, '0', qtgui_time_sink_x_0_0_4_0_1, '1']
- [network_tcp_source_0_0_6, '0', qtgui_const_sink_x_0, '0']
- [network_tcp_source_0_0_6, '0', qtgui_time_sink_x_0_0_4_0_0, '0']
- [network_tcp_source_0_0_6, '0', qtgui_time_sink_x_0_0_4_0_1, '0']
- [network_tcp_source_0_0_6, '0', qtgui_time_sink_x_0_0_4_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
